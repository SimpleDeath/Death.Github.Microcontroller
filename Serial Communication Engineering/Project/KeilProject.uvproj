# Keil uVision project KeilProject.uvproj, settings and files
target Main Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: KeilProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\Main;..\System;..\Library
  group Main
    ../Main/: main.c
  group System
    ../System/: interrupt.c common.c display.c keyboard.c rewrite.c uart.c
